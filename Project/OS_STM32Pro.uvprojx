# Keil uVision project OS_STM32Pro.uvprojx, settings and files
target Project (ARM-ADS)
  device: STM32F405RG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: OS_STM32Pro
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\APP;..\BSP;..\USER;..\FreeRTOS\inc;..\Sal
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App
    ../APP/: app.c
    ../App/: MainTask.c Control_Task.c USART_Task.c EncoderTask.c
  group Bsp
    ../BSP/: bsp_Init.c
    ../Bsp/: bsp_TIM.c bsp_HallInput.c bsp_Bluetooth.c bsp_Encoder.c bsp_CAN.c bsp_ADC.c
  group Sal
    ../Sal/: sal_PID.c sal_KalmanFilter.c
  group User
    ../USER/: main.c includes.h
    ../User/: stm32f4xx_it.c Johnbee_dbg.h
  group FreeRTOS
    ../FreeRTOS/src/: list.c port.c queue.c tasks.c timers.c heap_4.c event_groups.c
    ../FreeRTOS/: os_free_task.c
  group DOC
    ../DOC/: Readme.txt
software components: CMSIS:CORE 3.40.0, CMSIS:DSP 1.4.2, Device:Startup 1.3.1, Device:StdPeriph Drivers:ADC 1.3.0, Device:StdPeriph Drivers:CAN 1.3.0, Device:StdPeriph Drivers:DMA 1.3.0, Device:StdPeriph Drivers:FSMC 1.3.0, Device:StdPeriph Drivers:Flash 1.3.0, Device:StdPeriph Drivers:Framework 1.3.1, Device:StdPeriph Drivers:GPIO 1.3.0, Device:StdPeriph Drivers:RCC 1.3.0, Device:StdPeriph Drivers:TIM 1.3.0, Device:StdPeriph Drivers:USART 1.3.0
